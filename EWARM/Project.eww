<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Stm32H573_FreeRTOS_bsp.ewp</path>
  </project>
  <batchBuild />
</workspace>
